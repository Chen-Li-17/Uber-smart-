# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\ce;..\HARDWARE\EXTI;..\HARDWARE\PWM;..\HARDWARE\RUN;..\HARDWARE\TIM;..\HARDWARE\TIMER;..\STM32F10x_FWLib\inc;..\SYSTEM\malloc;..\HARDWARE\ATK-ESP8266;..\HARDWARE\USART2;..\HARDWARE\Ray
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RUN
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RUN/: RUN.c
    ../HARDWARE/TIMER/: timer.c
  group WIFI
    ../HARDWARE/ATK-ESP8266/: common.c
    ../HARDWARE/USART2/: usart2.c
  group SENSOR
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TIM/: TIM2.c
    ../HARDWARE/ce/: UltrasonicWave.c
    ../HARDWARE/Ray/: ray.c
